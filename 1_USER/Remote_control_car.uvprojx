# Keil uVision project Remote_control_car.uvprojx, settings and files
target DSS (5040049::V5.04 update 1 (build 49)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Remote_control_car +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\1_Main;.\2_Init;.\3_Once;.\4_While;.\5_Interrupt;.\6_Head_File;..\2_HARDWARE\1_Man-machine_interaction\0_Interaction;..\2_HARDWARE\1_Man-machine_interaction\1_LED;..\2_HARDWARE\1_Man-machine_interaction\2_Bluetooth;..\2_HARDWARE\1_Man-machine_interaction\3_OLED;..\2_HARDWARE\1_Man-machine_interaction\4_Button;..\2_HARDWARE\1_Man-machine_interaction\5_Labview;..\2_HARDWARE\2_Sensor\0_Get_Data;..\2_HARDWARE\2_Sensor\2_Measure_Distance\1_Ultrasonic;..\2_HARDWARE\2_Sensor\3_Measure_Status\1_MPU6050;..\2_HARDWARE\2_Sensor\4_Limit_Switch;..\2_HARDWARE\2_Sensor\5_Encoder;..\2_HARDWARE\3_Actuator\0_Actuator;..\2_HARDWARE\3_Actuator\1_Servo;..\2_HARDWARE\3_Actuator\2_Step_Motor;..\2_HARDWARE\3_Actuator\3_DC_Motor;..\2_HARDWARE\3_Actuator\4_BLDC_Motor;..\2_HARDWARE\3_Actuator\5_Air_Pump;..\2_HARDWARE\3_Actuator\6_Relay;..\2_HARDWARE\4_Internal_HAREWARE\0_Internal_Configuration;..\2_HARDWARE\4_Internal_HAREWARE\1_TIMER;..\2_HARDWARE\4_Internal_HAREWARE\2_IIC;..\2_HARDWARE\4_Internal_HAREWARE\3_EXTI;..\2_HARDWARE\4_Internal_HAREWARE\4_ADC;..\3_Arithmetic\0_Arithmetic;..\3_Arithmetic\1_PID\1_DC_Motor_PID;..\3_Arithmetic\2_Filter;..\4_STM32F10x_FWLib\inc;..\5_CORE;..\6_SYSTEM\delay;..\6_SYSTEM\Other;..\6_SYSTEM\sys;..\6_SYSTEM\usart;..\2_HARDWARE\2_Sensor\2_Get_Distance\1_Ultrasonic;..\2_HARDWARE\2_Sensor\3_Get_Status\1_MPU6050;..\2_HARDWARE\2_Sensor\4_Get_Station\1_Limit_Switch;..\2_HARDWARE\2_Sensor\5_Get_Velocity\1_Encoder;..\2_HARDWARE\2_Sensor\6_Get_Voltage;..\2_HARDWARE\4_Internal_HAREWARE\5_PWM;..\2_HARDWARE\4_Internal_HAREWARE\6_IO;..\2_HARDWARE\4_Internal_HAREWARE\7_USART;..\3_Arithmetic\4_DMP;..\2_HARDWARE\4_Internal_HAREWARE\8_Count;..\3_Arithmetic\5_String_Processing
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group 1_USER
    ./1_Main/: main.c
    ./2_Init/: Init.c
    ./3_Once/: once.c
    ./4_While/: while.c
    ./5_Interrupt/: Interrupt.c
    ./6_Head_File/: Canshu.h Struct.h
  group 1.5_Interface
    ../2_HARDWARE/1_Man-machine_interaction/0_Interaction/: Interaction.c
    ../2_HARDWARE/2_Sensor/0_Get_Data/: Get_Data.c
    ../2_HARDWARE/3_Actuator/0_Actuator/: Actuator.c
    ../2_HARDWARE/4_Internal_HAREWARE/0_Internal_Configuration/: Internal_Configuration.c
    ../3_Arithmetic/0_Arithmetic/: Arithmetic.c
  group 2_HARDWARE_Interaction
    ../2_HARDWARE/1_Man-machine_interaction/1_LED/: 1_LED.c
    ../2_HARDWARE/1_Man-machine_interaction/2_Bluetooth/: 2_Bluetooth.c
    ../2_HARDWARE/1_Man-machine_interaction/3_OLED/: 3_oled.c
    ../2_HARDWARE/1_Man-machine_interaction/4_Button/: 4_Button.c
  group 2_HARDWARE_Sensor
    ../2_HARDWARE/2_Sensor/6_Get_Voltage/: Get_Voltage.c
  group 2_HARDWARE_Actuator
    ../2_HARDWARE/3_Actuator/6_Relay/: Relay.c
    ../2_HARDWARE/3_Actuator/3_DC_Motor/: DC_Motor.c
  group 2_HARDWARE_Internal
    ../2_HARDWARE/4_Internal_HAREWARE/1_TIMER/: timer.c
    ../2_HARDWARE/4_Internal_HAREWARE/2_IIC/: IOI2C.c
    ../2_HARDWARE/4_Internal_HAREWARE/3_EXTI/: exti.c
    ../2_HARDWARE/4_Internal_HAREWARE/4_ADC/: ADC.c
    ../2_HARDWARE/4_Internal_HAREWARE/5_PWM/: PWM.c
    ../2_HARDWARE/4_Internal_HAREWARE/6_IO/: IO.c
    ../2_HARDWARE/4_Internal_HAREWARE/7_USART/: myusart.c
    ../2_HARDWARE/4_Internal_HAREWARE/8_Count/: Count.c
  group 3_Arithmetic
    ../3_Arithmetic/5_String_Processing/: String_Processing.c
  group 4_FWLib
    ../4_STM32F10x_FWLib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group 5_CORE
    ../5_CORE/: core_cm3.c startup_stm32f10x_md.s
  group 6_SYSTEM
    ../6_SYSTEM/delay/: delay.c
    ../6_SYSTEM/sys/: sys.c
    ../6_SYSTEM/usart/: usart.c
    ../6_SYSTEM/Other/: stm32f10x_it.c system_stm32f10x.c
  group 7_Readme
    ../8_Readme/: 1_This_Project_Note.txt 2_All_Note.txt 3_Template.txt 4_Exist_Bug.txt 5_Repaired_Bug.txt 6_Messy.txt
software components: CMSIS:CORE 3.20.0
